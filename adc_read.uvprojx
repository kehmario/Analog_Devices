# Keil uVision project adc_read.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.3.2.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x04000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: adc_read
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x4000
  group Source Group 1
    ./adc_channel_read/: adc_channel_read.c
